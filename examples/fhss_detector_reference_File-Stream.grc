options:
  parameters:
    author: J. Gilbert
    copyright: NTESS, LLC
    description: Reference Application
    generate_options: qt_gui
    id: fhss_detector_reference_b200
    output_language: python
    title: Burst Detector Reference
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Center Freq
    orient: Qt.Horizontal
    start: 100e6
    step: 1e6
    stop: 2000e6
    value: 915e6
  states: {}
- name: decim_taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1, 1, output_cutoff/decimation, output_trans_width/decimation, output_attenuation)
  states: {}
- name: fir_taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1, 1, 0.5*output_cutoff, 0.5*output_trans_width, output_attenuation)
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '70'
    value: '60'
  states: {}
- name: syncwords
  id: variable
  parameters:
    comment: |-
      UPDATE ME! 
      Change the syncwords to match bursts of interest
    value: '''10101010101010101010101010101010101010101010101010'''
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,2,1,1
    label: Threshold
    orient: Qt.Horizontal
    start: '3'
    step: '1'
    stop: '40'
    value: '6'
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '19200'
    gain: '1.0'
    samp_rate: (samp_rate/decimation)
    width: '9600'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/hash/Desktop/915Mhz_2.5MSPS.uc8
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_debug_0_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_1_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: pow(2,-15) * pow(2,((gain)/2.2))
    minoutbuf: '1024000'
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    comment: |-
      Enable the Message Debug ---->
      and disable the throttle block
      for benchmarking performance
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate/1
    type: complex
  states: {}
- name: burst_width
  id: parameter
  parameters:
    hide: part
    label: Burst Width [Hz]
    type: intx
    value: int(100e3)
  states: {}
- name: cfo_start_offset
  id: parameter
  parameters:
    label: CFO Start Offset [s]
    type: eng_float
    value: '0'
  states: {}
- name: cfo_threshold
  id: parameter
  parameters:
    label: CFO threshold
    type: eng_float
    value: '0.5'
  states: {}
- name: cfo_time_to_average
  id: parameter
  parameters:
    label: CFO Average Time [s]
    type: eng_float
    value: '0.0005'
  states: {}
- name: decimation
  id: parameter
  parameters:
    label: Decimation
    type: intx
    value: int(256/10)
  states: {}
- name: fft_size
  id: parameter
  parameters:
    label: FFT Size
    type: intx
    value: int(1024/10)
  states: {}
- name: fhss_utils_cf_estimate_0
  id: fhss_utils_cf_estimate
  parameters:
    channel_freqs: '[]'
    method: '0'
  states: {}
- name: fhss_utils_fft_burst_tagger_0
  id: fhss_utils_fft_burst_tagger
  parameters:
    burst_post_len: int(round((float(samp_rate)/fft_size)*post_burst_time))
    burst_pre_len: int(round((float(samp_rate)/fft_size)*pre_burst_time))
    burst_width: burst_width
    center_frequency: center_freq
    debug: 'False'
    fft_size: fft_size
    history_size: int(round((float(samp_rate)/fft_size)*hist_time))
    lookahead: int(round((float(samp_rate)/fft_size)*lookahead_time))
    max_burst_len: '0'
    max_bursts: '0'
    minoutbuf: 2048*1000
    sample_rate: samp_rate
    threshold: threshold
  states: {}
- name: fhss_utils_tagged_burst_to_pdu_0
  id: fhss_utils_tagged_burst_to_pdu
  parameters:
    decimation: decimation
    max_burst_time: max_burst_time
    min_burst_time: min_burst_time
    relative_center_frequency: '0.0'
    relative_sample_rate: '1.0'
    relative_span: '1.0'
    sample_rate: samp_rate
    taps: decim_taps
    threads: '3'
  states: {}
- name: hist_time
  id: parameter
  parameters:
    hide: part
    label: History Time [s]
    type: eng_float
    value: '0.004'
  states: {}
- name: lookahead_time
  id: parameter
  parameters:
    hide: part
    label: Lookahead Time [s]
    type: eng_float
    value: '0.0005'
  states: {}
- name: max_burst_time
  id: parameter
  parameters:
    hide: part
    label: Max Burst Time [s]
    type: eng_float
    value: '0.5'
  states: {}
- name: min_burst_time
  id: parameter
  parameters:
    hide: part
    label: Min Burst Time [s]
    type: eng_float
    value: '0.020'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      .                                                                                                                                                                                                                                  Burst Detection
      ------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
    note: SECTION
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: |-
      .                                                                                                                                                                                                                                  Tuning Parameters
      ------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
    note: SECTION
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    comment: |-
      .                                                                                                                                                                                                                                  Input
      ------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
    note: SECTION
  states: {}
- name: note_0_1
  id: note
  parameters:
    comment: |-
      .                                                                                                                                                                                                                                  FM Demod and Symbol Recovery
      ------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
    note: SECTION
  states: {}
- name: note_0_1_0
  id: note
  parameters:
    comment: |-
      .                                                                                                                                                                                                                                  Align and Decode Select Bursts				
      ------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
    note: SECTION
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      Both the Hier and discrete implementations
      are available here; choose one or the other.
    note: OPTION
  states: {}
- name: note_2_0
  id: note
  parameters:
    note: ====> DEFRAMER
  states: {}
- name: output_attenuation
  id: parameter
  parameters:
    hide: part
    label: Output Attenuation
    type: eng_float
    value: '40'
  states: {}
- name: output_cutoff
  id: parameter
  parameters:
    hide: part
    label: Output Cutoff [cycles/samp]
    type: eng_float
    value: '0.5'
  states: {}
- name: output_trans_width
  id: parameter
  parameters:
    hide: part
    label: Output Trans. Width [cycles/samp]
    type: eng_float
    value: '0.05'
  states: {}
- name: pdu_utils_pdu_align_0
  id: pdu_utils_pdu_align
  parameters:
    offset: '0'
    syncwords: syncwords
    threshold: '0'
  states: {}
- name: pdu_utils_pdu_clock_recovery_0
  id: pdu_utils_pdu_clock_recovery
  parameters:
    binary_slice: none
    debug: 'False'
    win_type: pdu_utils.TUKEY_WIN
  states: {}
- name: pdu_utils_pdu_clock_recovery_0_0
  id: pdu_utils_pdu_clock_recovery
  parameters:
    binary_slice: binary
    debug: 'False'
    win_type: pdu_utils.TUKEY_WIN
  states: {}
- name: pdu_utils_pdu_fine_time_measure_0
  id: pdu_utils_pdu_fine_time_measure
  parameters:
    average_width: '10'
    buffer_percent: '15'
    post_burst_time: post_burst_time
    pre_burst_time: pre_burst_time
  states: {}
- name: pdu_utils_pdu_fir_filter_0
  id: pdu_utils_pdu_fir_filter
  parameters:
    decimation: '1'
    taps: variable_low_pass_filter_taps_0
  states: {}
- name: pdu_utils_pdu_fir_filter_1
  id: pdu_utils_pdu_fir_filter
  parameters:
    decimation: '2'
    taps: fir_taps
  states: {}
- name: pdu_utils_pdu_quadrature_demod_cf_0
  id: pdu_utils_pdu_quadrature_demod_cf
  parameters:
    sensitivity: '1.0'
  states: {}
- name: pdu_utils_pdu_split_0_0
  id: pdu_utils_pdu_split
  parameters:
    comment: |-
      Enable the Message Debug ---->
      to see PDU Metadata printed
    pass_empty: 'False'
  states: {}
- name: post_burst_time
  id: parameter
  parameters:
    hide: part
    label: Post Burst Time [s]
    type: eng_float
    value: '0.00008'
  states: {}
- name: pre_burst_time
  id: parameter
  parameters:
    hide: part
    label: Pre Burst Time [s]
    type: eng_float
    value: '0.00008'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,1,1,1
    label1: ''
    name: '"FM Demodulation"'
    size: '102400'
    srate: samp_rate/decimation
    tr_delay: '.001'
    tr_level: '0.000001'
    type: msg_float
    update_time: '0.01'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,2,1,1
    label1: ''
    marker1: '0'
    name: '"Soft Symbols"'
    size: '102400'
    srate: '1'
    style1: '0'
    tr_delay: '.001'
    tr_level: '0.000001'
    type: msg_float
    update_time: '0.01'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decimation/2
    fc: '0'
    fftsize: '128'
    gui_hint: 1,0,1,1
    name: '"Burst Spectrogram"'
    showports: 'True'
    type: msg_complex
    update_time: '0.005'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,3
    int_max: '0'
    int_min: '-120'
    name: '"Input Spectrogram"'
    showports: 'True'
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: r
    type: intx
    value: int(2.5e6)
  states: {}
- name: smart_meters_GridStream_0
  id: smart_meters_GridStream
  parameters:
    crcEnable: 'False'
    crcInitialValue: '0x5FD6'
    meterMonitorID: '0x00'
    packetLengthFilter: '0x00'
    packetTypeFilter: '0x00'
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: center_freq
    clock_rate: '0.0'
    dc_offs_enb0: 'True'
    dev_args: '"num_recv_frames=1024"'
    gain0: gain
    iq_imbal_enb0: 'True'
    minoutbuf: 2048*1000
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: input
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: bursts
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: hard_syms
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: input
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: input
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: bursts
  states: {}
- name: virtual_source_0_2_0
  id: virtual_source
  parameters:
    stream_id: hard_syms
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', virtual_sink_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0_1_0, print]
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [fhss_utils_cf_estimate_0, out, pdu_utils_pdu_fir_filter_1, pdu_in]
- [fhss_utils_fft_burst_tagger_0, '0', fhss_utils_tagged_burst_to_pdu_0, '0']
- [fhss_utils_tagged_burst_to_pdu_0, cpdus, fhss_utils_cf_estimate_0, in]
- [pdu_utils_pdu_align_0, pdu_out, smart_meters_GridStream_0, pdu_in]
- [pdu_utils_pdu_clock_recovery_0, pdu_out, pdu_utils_pdu_split_0_0, pdu_in]
- [pdu_utils_pdu_clock_recovery_0, pdu_out, qtgui_time_sink_x_0_0_0_0_0_0_0_0, in]
- [pdu_utils_pdu_clock_recovery_0_0, pdu_out, virtual_sink_0_0_0, '0']
- [pdu_utils_pdu_fine_time_measure_0, pdu_out, virtual_sink_0_0, '0']
- [pdu_utils_pdu_fir_filter_0, pdu_out, pdu_utils_pdu_clock_recovery_0, pdu_in]
- [pdu_utils_pdu_fir_filter_0, pdu_out, pdu_utils_pdu_clock_recovery_0_0, pdu_in]
- [pdu_utils_pdu_fir_filter_0, pdu_out, qtgui_time_sink_x_0_0_0_0_0, in]
- [pdu_utils_pdu_fir_filter_1, pdu_out, pdu_utils_pdu_fine_time_measure_0, pdu_in]
- [pdu_utils_pdu_quadrature_demod_cf_0, fpdus, pdu_utils_pdu_fir_filter_0, pdu_in]
- [pdu_utils_pdu_split_0_0, dict, blocks_message_debug_0_1, print]
- [smart_meters_GridStream_0, pdu_out, blocks_socket_pdu_0, pdus]
- [uhd_usrp_source_1, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', fhss_utils_fft_burst_tagger_0, '0']
- [virtual_source_0_0, '0', blocks_probe_rate_0, '0']
- [virtual_source_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [virtual_source_0_2, '0', pdu_utils_pdu_quadrature_demod_cf_0, cpdus]
- [virtual_source_0_2, '0', qtgui_waterfall_sink_x_0, in]
- [virtual_source_0_2_0, '0', pdu_utils_pdu_align_0, pdu_in]

metadata:
  file_format: 1
